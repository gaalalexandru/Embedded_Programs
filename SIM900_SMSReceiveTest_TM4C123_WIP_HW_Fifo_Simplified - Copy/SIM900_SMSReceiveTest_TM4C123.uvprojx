# Keil uVision project SIM900_SMSReceiveTest_TM4C123.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BlankProjekt_TM4C
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123GH6PM
  c include: ..\..\TivaWare_C_Series-2.1.1.71
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c GSM.c uart_handler.c SecSys_Config.h pc_display.c fifo.c
  group Drivers
    ../../TivaWare_C_Series-2.1.1.71/driverlib/rvmdk/: driverlib.lib
    ../../TivaWare_C_Series-2.1.1.71/utils/: uartstdio.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
