# Keil uVision project Receive_SMS_GSM_Library.uvproj, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Receive_SMS_GSM_Library +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s Arduino.h IPAddress.h
  group New Group
    ./src/: GSM3CircularBuffer.cpp GSM3MobileAccessProvider.cpp GSM3MobileCellManagement.cpp GSM3MobileClientProvider.cpp GSM3MobileClientService.cpp GSM3MobileDataNetworkProvider.cpp GSM3MobileMockupProvider.cpp GSM3MobileNetworkProvider.cpp GSM3MobileNetworkRegistry.cpp GSM3MobileServerProvider.cpp GSM3MobileServerService.cpp GSM3MobileSMSProvider.cpp GSM3MobileVoiceProvider.cpp GSM3ShieldV1.cpp GSM3ShieldV1AccessProvider.cpp GSM3ShieldV1BandManagement.cpp GSM3ShieldV1BaseProvider.cpp GSM3ShieldV1CellManagement.cpp GSM3ShieldV1ClientProvider.cpp GSM3ShieldV1DataNetworkProvider.cpp GSM3ShieldV1DirectModemProvider.cpp GSM3ShieldV1ModemCore.cpp GSM3ShieldV1ModemVerification.cpp GSM3ShieldV1MultiClientProvider.cpp GSM3ShieldV1MultiServerProvider.cpp GSM3ShieldV1PinManagement.cpp GSM3ShieldV1ScanNetworks.cpp GSM3ShieldV1ServerProvider.cpp GSM3ShieldV1SMSProvider.cpp GSM3ShieldV1VoiceProvider.cpp GSM3SMSService.cpp GSM3SoftSerial.cpp GSM3VoiceCallService.cpp
