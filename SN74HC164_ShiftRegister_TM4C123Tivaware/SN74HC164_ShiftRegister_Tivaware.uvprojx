# Keil uVision project SN74HC164_ShiftRegister_Tivaware.uvprojx, settings and files
target Nokia5110 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: SN74HC164_Test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RA1
  c include: ..;..\..\..;..\..\inc;..\..\TivaWare_C_Series-2.1.1.71\driverlib;..\..\TivaWare_C_Series-2.1.1.71
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: PLL.c SN74HC164_TestMain.c SSI_handler_tivaware.c startup_new.s
    ../../TivaWare_C_Series-2.1.1.71/driverlib/rvmdk/: driverlib.lib
