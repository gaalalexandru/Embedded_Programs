# Keil uVision project ToggleLED_TM4C.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: BlankProjekt_TM4C +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PART_TM4C123GH6PM
  c include: ..\..\tools\TivaWare_C_Series-2.1.1.71
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c uart_handler.c
  group Drivers
    ../../tools/TivaWare_C_Series-2.1.1.71/driverlib/rvmdk/: driverlib.lib
software components: CMSIS:CORE 5.0.0, Device:Startup 1.0.1
