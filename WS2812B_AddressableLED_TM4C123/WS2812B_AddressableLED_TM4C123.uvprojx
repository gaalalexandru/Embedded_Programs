# Keil uVision project WS2812B_AddressableLED_TM4C123.uvprojx, settings and files
target WS2812B (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: WS2812B_Test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c include: ..;..\..\..;..\..\inc;..\..\TivaWare_C_Series-2.1.1.71\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c SSI_handler.c WS2812B_TestMain.c UART_handler.c
